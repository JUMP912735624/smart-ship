# Keil uVision project Flow-master.uvprojx, settings and files
target Flow-master (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x00200000) IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MasterProcessor +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --gnu
  c include: .\Code\inc;.\Code\lib;.\Code\lib\STM32F4xx_StdPeriph_Driver\inc;.\Code\lib\STM32_USB_Device_Library\Class\cdc\inc;.\Code\lib\STM32_USB_Device_Library\Core\inc;.\Code\lib\STM32_USB_HOST_Library\Core\inc;.\Code\lib\STM32_USB_OTG_Driver\inc;.\Code\mavlink\include\mavlink\v1.0;.\Code\mavlink\include\mavlink\v1.0\common
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --keep __fsym_* --keep __vsym_*
  group Applications
    ./Code/src/: communication.c dcmi.c debug.c flow.c gyro.c i2c.c led.c mt9v034.c reset.c settings.c sonar.c sonar_mode_filter.c usart.c usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c utils.c
  group STM32_StdPeriph
    ./Code/src/: stm32f4xx_it.c main.c system_stm32f4xx.c
    ./Code/lib/: startup_stm32f4xx.s
    ./Code/lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c
    ./Code/lib/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
    ./Code/lib/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ./Code/lib/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
